# Keil uVision project stm32f1.uvprojx, settings and files
target stm32f103c8 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c include: ../../source/app;../../source/lib;../../source/hal;../../source/hil/stm32/cmsis;../../source/hil/stm32/stm32f1;../../source/hil/stm32/driverlib_stm32f1_v3.5.0/inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../../source/app/: app.c
  group lib
    ../../source/lib/: comm.c sch.c error.c
  group hil
    ../../source/hil/stm32/stm32f1/: io.c main.c sys.c uart.c system_stm32f10x.c
    ../../source/hil/stm32/keil_startup/: startup_stm32f10x_md.s
  group driverlib
    ../../source/hil/stm32/driverlib_stm32f1_v3.5.0/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
