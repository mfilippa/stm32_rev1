# Keil uVision project stm32f4.uvprojx, settings and files
target stm32f415rg (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F415RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f415rg
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER
  c include: ../../source/app;../../source/lib;../../source/hal;../../source/hil/stm32/cmsis;../../source/hil/stm32/stm32f4;../../source/hil/stm32/driverlib_stm32f4_v1.8.0/inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../source/app/: app.c
  group lib
    ../../source/lib/: comm.c sch.c error.c
  group hil
    ../../source/hil/stm32/stm32f4/: io.c main.c sys.c system_stm32f4xx.c uart.c
    ../../source/hil/stm32/keil_startup/: startup_stm32f40_41xxx.s
  group driverlib
    ../../source/hil/stm32/driverlib_stm32f4_v1.8.0/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
