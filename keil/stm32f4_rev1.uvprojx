# Keil uVision project stm32f4_rev1.uvprojx, settings and files
target debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F415RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4_rev1
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, __FPU_PRESENT = 1
  c include: ..\source;..\source\hw;..\source\hw\cmsis;..\source\hw\driverlib_v1.8.0\inc
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../source/app/: app.c
  group lib
    ../source/lib/: sch.c comm.c debug.c fb.c sm.c math.c
  group hw
    ../source/hw/: main.c system_stm32f4xx.c startup_stm32f40_41xxx.s io.c sys.c uart.c pwm.c adc.c i2c.c
  group driverlib
    ../source/hw/driverlib_v1.8.0/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_i2c.c
  group cmsis
    ../source/hw/cmsis/: arm_cortexM4lf_math.lib
